Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2020-08-08T10:42:26
Written by: Xbim File Processor version 4.0.0.0
Made in: Xbim version 4.0.0.0

# IfcDistributionPort (2)
Name | FlowDirection
 | SOURCE
 | SINK

# IfcFlowTerminal: Bornholm 2 Under water
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: Bornholm 2 Under water; Light output ratio: 1; Luminous flux: 843 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 843 lm; LightEmitterNominalPower: 9 W; Spectrum: 380: 12934, 385: 1155, 390: 11614, 395: 10494, 400: 10484, 405: 10279, 410: 968, 415: 11352, 420: 17493, 425: 49381, 430: 110001, 435: 213323, 440: 422394, 445: 673726, 450: 939462, 455: 97829, 460: 851938, 465: 670014, 470: 549521, 475: 442322, 480: 39367, 485: 37832, 490: 392506, 495: 423255, 500: 468951, 505: 509823, 510: 551923, 515: 57673, 520: 59894, 525: 611155, 530: 623829, 535: 629598, 540: 636475, 545: 645361, 550: 655589, 555: 671682, 560: 690295, 565: 709359, 570: 730587, 575: 748998, 580: 767832, 585: 786295, 590: 801043, 595: 812518, 600: 821303, 605: 827334, 610: 827494, 615: 819016, 616: 814072, 617: 810179, 618: 806287, 619: 802012, 620: 797737, 625: 764787, 630: 724964, 635: 680899, 640: 638133, 645: 594845, 650: 555125, 655: 51894, 660: 486181, 665: 454614, 670: 422297, 675: 388355, 680: 352992, 685: 318193, 690: 282697, 695: 245701, 700: 215906, 705: 189853, 710: 163229, 715: 14476, 720: 12737, 725: 114158, 730: 97674, 735: 85444, 740: 75708, 745: 68751, 750: 61453, 755: 56451, 760: 52251; ColorRenderingIndex: 80

# IfcFlowTerminal: Bornholm 2 Underwater luminaires
In: Default Building
Type - Description: - Lamp LED - CRI Ra > 80 - MacAdam Ellipse 3 SDCM - Colour 3000K and 4000K - Stainless steel body and fasteners in grade 316 - Single cable entry - One cable gland supplied with 2 m of 2x1.0 sqmm outdoor cable - Durable silicone rubber gasket - Clear toughened glass - Maximum depth 1.5 meters - Luminaire must be submerged when operational - Recessing box in stainless steel 316 grade - Remote driver for constant current (CC) is included, for constant voltage (CV) not included - Remote IP box is not included - Outdoor cable needs to be ordered with a specific length; PredefinedType: DIRECTIONSOURCE
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: Bornholm, Underwater; Housing color: White, Black, Silver
General Information - Article number: BOH-60013-M-8040; Article name: Bornholm 2 Underwater luminaires; Weight: 1.6 kg; Case height: 10.3 cm; Case diameter: 15 cm; Uld creation date: 08.08.2020 00:00:00
Mounting Information - Mounting height: 0.6 cm; Recessed depth: 0.6 cm
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 9 W
Pset_LightFixtureTypeCommon - NumberOfSources: 1; TotalWattage: 9 W; LightFixtureMountingType: WallRecessed; LightFixturePlacingType: Wall; ManufacturersSpecificInformation: LIGMAN
